SRC_URI += "file://user_2020-01-27-12-46-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

